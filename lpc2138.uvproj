# Keil uVision project lpc2138.uvproj, settings and files
target lpc2138 (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: lpc2138 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group startup
    ./: Startup.s
  group USR
    ./USR/: mian.c TargetInit.c
  group uCOSII
    ./uCOS-II/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ARM
    ./ARM/: os_cpu_a.s os_cpu_c.c
